# Keil uVision project mx7.uvproj, settings and files
target mx7 (ARM-ADS)
  device: LPC11C24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: mx7 +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: ..\source\core_cm0;..\source\interrupt;..\source\main;..\source\mcu_drive;..\source\uart;..\source\model_define;..\source\mpu;..\source\power;..\source\message;..\source\lib;..\source\can
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../source/mcu_drive/: startup_LPC11xx.s
  group Cmsis
    ../source/core_cm0/: core_cm0.c
  group mcu_drive
    ../source/mcu_drive/: AHB_clock_ctrl.c lpc11cXX_gpio.c system_LPC11xx.c systick.c test_clock_source.c watchdog.c
  group main
    ../source/main/: main.c lib.c
  group interrupt
    ../source/interrupt/: interrupt.c remap_interrupt.c
  group uart
    ../source/uart/: uart_drv.c
  group debug
    ../source/debug/: retarget.c
  group mpu
    ../source/mpu/: mpu.c mpu_rx.c mpu_tx.c
  group power
    ../source/power/: main_power.c mpu_power.c can_power.c
  group message
    ../source/message/: message.c
  group can
    ../source/can/: can.c can_drv.c can_tx.c can_rx.c
